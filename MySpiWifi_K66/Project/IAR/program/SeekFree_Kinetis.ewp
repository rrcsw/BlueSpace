# IAR project SeekFree_Kinetis.ewp, settings and files
configuration MK66FX_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\M8266WIFI\inc; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkIcfFile: linker\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60_adc.h MK60_cmt.h MK60_dac.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_systick.h MK60_uart.h MK60_wdog.h
  group drives/src
    ../../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group Framework/app
    ../../USER/src/: application.c
    ../../USER/inc/: application.h
  group Framework/app/main
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/src/: isr.c main.c
    ../../USER/inc/: isr.h macro.h
  group Framework/app/meeting_car
    ../../USER/src/: fsm.c
    ../../USER/inc/: fsm.h
  group Framework/communication
    ../../USER/src/: communication.c message.c
    ../../USER/inc/: communication.h message.h
  group Framework/control
    ../../USER/src/: control.c
    ../../USER/inc/: control.h
  group Framework/decision
    ../../USER/src/: decision.c
    ../../USER/inc/: decision.h
  group Framework/perception
    ../../USER/src/: perception.c
    ../../USER/inc/: perception.h
  group Framework/util
    ../../USER/src/: deque.c pid.c queue.c timer.c util.c
    ../../USER/inc/: deque.h pid.h queue.h timer.h util.h
  group seekfree
    ../../../Libraries/seekfree/: SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK66F18.s
    ../../../Libraries/startup/DeviceSupport/: system_MK66.c
  group wifi/inc
    ../../../Libraries/M8266WIFI/inc/: brd_cfg.h M8266HostIf.h M8266WIFI_ops.h M8266WIFIDrv.h
  group wifi/src
    ../../../Libraries/M8266WIFI/src/: M8266HostIf.c M8266WIFI_ops.c test_m8266wifi.c
    ../../../Libraries/M8266WIFI/: M8266WIFIDrv_K60.a
